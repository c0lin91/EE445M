# Keil uVision project Lab04.uvproj, settings and files
target Lab04 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab03
  c flags: Optim=1
  c include: ..;..\..\..;..\driverlib\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./: main.c
  group OS
    ./: OS.c TCB.c SysTick.c OS_Time.c OS_Fifo.c OS_Mailbox.c OS_Display.c OS_Interpreter.c OSasm.s startup.s
  group Peripherals
    ./: PLL.c ST7735.c UART.c ADC.c GPIO.c can.c can0.c Timer3.c interrupt.c PING.c PWM.c
  group External Libs
    ./: cr4_fft_64_stm32.s
