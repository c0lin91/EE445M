# Keil uVision project PeriodicSysTickInts.uvproj, settings and files
target PeriodicSysTickInts (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: PeriodicSysTickInts
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;..\..\fftw-3.3.3-dll32;..\PeriodicSysTickInts_4F120
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PeriodicSysTickInts.c PLL.c ADC.c ADCSWTrigger.h ADCSWTrigger.c fftw3.h libfftw3-3.lib DAC.c DAC.h
