# Keil uVision project SDC.uvproj, settings and files
target SDC (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SDC
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s SDCTestMain.c eDisk.c PLL.c OS.c osasm.s UART2.c adc.c Interpreter.c efile.c Filter.c cr4_fft_64_stm32.s SysTick.c
  group Library
    ./: OS.h edisk.h PLL.h UART2.h FIFO.h adc.h efile.h Filter.h SysTick.h
