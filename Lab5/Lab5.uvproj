# Keil uVision project Lab5.uvproj, settings and files
target Lab5 (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ST7735
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..;..\driverlib\..
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: startup.s ADC.c Interpreter.c OS.c PLL.c ST7735.c SysTick.c UART2.c cr4_fft_64_stm32.s osasm.s PID_stm32.s main.c Filter.c FIFO.h efile.c edisk.c
  group Library
    ../driverlib/rvmdk-cm4f/: driverlib-cm4f.lib
